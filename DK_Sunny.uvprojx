# Keil uVision project DK_Sunny.uvprojx, settings and files
target TDID(消费机) (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SOCKET_ID_03 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\FWlib\inc;.\CommonDevDriver;.\CM3;.\uCOS-II\Ports;.\uCOS-II\Source;.\uCOS-II\uC-CPU;.\APP;.\StdPeripheralByDK;.\Define;.\POS;.\cJSON;..\新平台ID程序系统
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: stm32f10x_startup.s
  group APP
    ./APP/: main.c stm32f10x_it.c
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_tim.c misc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c
  group CM3
    ./CM3/: core_cm3.c system_stm32f10x.c
  group uC-OS-II/Port
    ./uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/CPU
    ./uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ./uCOS-II/Source/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group CommonDevDriver
    ./CommonDevDriver/: bsp.c AT24C64.C delay.c Disp_1629DFile.C ScanKeyFiles.C W5500.c watchdog.c PCF8563.C MFRC522.c MoNiSPI.C AT24C256.C SPI_FLASH.C 485.C
  group StdPeripheralByDK
    ./StdPeripheralByDK/: FSMC.c GPIO.C NVIC.C TIME.C USART.C hw_config.c variable.H char.H externvariable.H hw_config.h iic.c DK_SPI.C
  group Define
    ./Define/: char.H externvariable.H MyDefine.H variable.H
  group POS
    ./POS/: CalucationFile.c InitSetParameterFile.C SetW5500Net.c ConsumSubFile.C ISO7816File.c PSAM_Files.c RecordFiles.C
  group USR
    ./: Task_eth_rec_Data.c ReadWriteCardTask.c
    ./cJSON/: cJSON.c
    ./POS/: downfile.c
    ./APP/: uploadrecord.c dns.c dhcp.c
software components: CMSIS:CORE 5.0.0
